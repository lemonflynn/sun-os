# Keil uVision project sun_os.uvprojx, settings and files
target Hack (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sun_os
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c include: .\App\Inc;.\Arch\STM32F4\CMSIS\Device\ST\STM32F4xx\Include;.\Arch\STM32F4\CMSIS\Include;.\Arch\STM32F4\STM32F4xx_HAL_Driver\Inc;.\Arch\STM32F4\BSP\STM32F4xx_Nucleo_144;.\OS\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Driver
    ./Arch/STM32F4/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
    ./Arch/STM32F4/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c
  group App
    ./App/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c led.c stm32f4xx_hal_msp.c uart.c
    ./: startup_stm32f429xx.s
  group OS
    ./OS/Src/: sun_semaphore.c sun_task.c sun_timer.c sun_ipc.c
